# IAR project s2w.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TX_ENABLE_IAR_LIBRARY_SUPPORT; IAR; FIXED_ROM_BUILD; RUN_ALL_FROM_FLASH; TM_USE_HTTPD; S2W_DNS_CLIENT; NX_INCLUDE_USER_DEFINE_FILE; S2W_WEB_FS_AVAILABLE; S2W_EXTFLASH_DRIVER_TEST; S2W_PWM_SUPPORT; S2W_MEM_ACCESS; S2W_FORCE_UART_PORT; S2W_EXT_FLASH_FWUP_PUSH_METHOD; S2W_NCM_SUPPORT_ENABLE; S2W_SECURITY_ENTERPRISE_PEAP_V0_AVAILABLE; S2W_EXT_FLASH_FWUP_PULL_METHOD; S2W_SECURITY_ENTERPRISE_TLS_AVAILABLE; S2W_DNS_SERVER_ENABLE; ADK_OTAFU; S2W_GSLINK_RAW; S2W_GSLINK_XML; S2W_SECURITY_ENTERPRISE_PEAP_V1_AVAILABLE; S2W_PING_TRACE; S2W_RF_TEST; S2W_SSL_CLIENT_SUPPORT; S2W_DEFAULT_UART_PARITY=0; S2W_DHCP_SERVER_ENABLE; S2W_SECURITY_WPS_ENABLE; ADK_PROV_CONFIG_LIMITED_AP; S2W_WEB_SERVER; ADK_PROV; S2W_DEFAULT_UART_SW_FLOW=0; S2W_FILE_UPLOAD_API; S2W_COAP_SUPPORT; S2W_HTTPD_SSLCERT_UPLOAD; S2W_DEFAULT_UART_STOP_BITS=0; S2W_FACT_IMAGE_REQ; S2W_DEFAULT_UART_BAUD=9600; S2W_ASYNC_MSG; S2W_HTTPS_SUPPORT; S2W_DEFAULT_UART_HW_FLOW=0; S2W_SECURITY_ENTERPRISE_FAST_GTC_AVAILABLE; S2W_WEB_PROV; S2W_UNASSOC_TXRX_SUPPORT; S2W_SNTP; S2W_UART_ENABLE; S2W_GSLINK_XMLNESTED_PARSER; S2W_GSLINK; S2W_SECURITY_ENTERPRISE_TTLS_AVAILABLE; S2W_ADC_SUPPORT; S2W_HTTPC_SUPPORT; S2W_SECURITY_ENTERPRISE_FAST_MSCHAPV2_AVAILABLE; S2W_SSL_SERVER_SUPPORT; ADK_PROV_CONFIG_CLIENT; S2W_DEFAULT_UART_BITS_PER_CHAR=3; S2W_MDNS_ENABLE
  ICCARM.CCDiagSuppress: Pa050, Pe231, Pe177
  ICCARM.CCIncludePath2: ..\..\..\geps\inc; ..\..\..\geps\inc\core; ..\..\..\geps\inc\drivers; ..\..\..\geps\inc\modules; ..\..\..\geps\inc\rtos; ..\..\..\geps\inc\netx; ..\..\..\geps\inc\netx\netx_bsd_layer; ..\..\..\geps\inc\main; ..\..\..\geps\inc\fs; ..\..\..\geps\inc\fs\hcc\src; ..\..\..\geps\inc\security\src\; ..\..\..\geps\inc\security\hw_engine_if; ..\..\..\geps\inc\security\wpa_if; ..\..\..\userlib\ncm\inc; ..\..\..\userlib; ..\inc\ctx; ..\inc; ..\inc\main; ..\inc\hal; ..\inc\parser; ..\inc\config; ..\src; ..\..\..\adk\otafu\inc; ..\..\..\adk\provisioning\inc; ..\inc\mqtt; ..\src\mqtt; ..\inc\one_wire; ..\src\one_wire; ..\inc\linked_list; ..\src\linked_list; ..\inc\mqtt_main; ..\src\mqtt_main; ..\inc\mqtt_log; ..\src\mqtt_log
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: app_flashFetch.icf
  ILINK.IlinkExtraOptions: -f ..\..\..\geps\lib\rom_patch_fpt_symbols.txt; --keep rom_patch_auto_dummy1; --keep rom_patch_auto_dummy2; --entry GsnStartup_Main; --redirect malloc=MALLOC; --redirect free=FREE
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: s2w.srec
  ILINK.IlinkOutputFile: uart_test.out
  group (top)
    ../src/clk_tune/: app_clk_tune.c
    ../src/emu/: app_emu.c
    ../src/ext_app/: app_ext_flash.c
    ../src/main/: app_main.c app_main_thread.c s2w_l2_dev.c
    ../src/gslink/: app_mcu_http_api.c
    ../src/rtc_mem/: app_rtc_mem.c
    ./: gsn_flash_startup.c
    ../../../geps/lib/: gsn_modules_flash.a rom-final.a rom_patch_app.a rom_patch_auto.a rom_patch_fpt.a
    ../../../adk/otafu/lib/: otafu.a
    ../src/parser/: s2w_154_command.c s2w_ext_flash_command.c s2w_general_command.c s2w_general_parse.c s2w_misc_command.c s2w_process.c s2w_zip_command.c
    ../src/hal/: s2w_app_batt_chk.c s2w_app_hal_general.c s2w_cert_mgmt.c s2w_cfg.c s2w_ext_flash_fwup.c s2w_fs_if.c s2w_net_gainspan.c s2w_os_gainspan.c
    ../src/web_prov/: s2w_web_prov.c
    ../../../adk/provisioning/lib/: web_prov.a
  group FTW-MQTT
    ../src/mqtt_main/: mqtt_main.c
    ../inc/mqtt_main/: mqtt_main.h
  group linked_list
    ../src/linked_list/: linked_list.c
    ../inc/linked_list/: linked_list.h
  group mqtt
    ../src/mqtt/: libmqtt.c
    ../inc/mqtt/: libmqtt.h
  group MQTT_LOG
    ../src/mqtt_log/: mqtt_log.c
    ../inc/mqtt_log/: mqtt_log.h
  group ncm
    ../../../userlib/ncm/src/: gsn_ncm.c gsn_ncm_roam.c
  group one_wire
    ../src/one_wire/: one_wire.c
    ../inc/one_wire/: one_wire.h
